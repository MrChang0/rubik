# Keil uVision project ov7725.uvprojx, settings and files
target OV 2205 (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: ov7725
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: ..\user;..\user\lcd;..\user\ov7725;..\user\sccb;..\user\usart;..\user\color;..\user\TimBase;..\user\rubik;..\user\mofang
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ../user/sccb/: bsp_sccb.c
    ../user/ov7725/: bsp_ov7725.c
    ../user/lcd/: bsp_ili9341_lcd.c
    ../user/color/: color.c
    ../user/TimBase/: bsp_TiMbase.c
    ../user/: main.c
    ../user/rubik/: rubik.c
    ../user/mofang/: control.c mofang.c USART1.c
software components: CMSIS:CORE 4.1.0, Device:Startup 1.0.0, Device:StdPeriph Drivers:DMA 3.5.0, Device:StdPeriph Drivers:EXTI 3.5.0, Device:StdPeriph Drivers:FSMC 3.5.0, Device:StdPeriph Drivers:Flash 3.5.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0, Device:StdPeriph Drivers:TIM 3.5.0, Device:StdPeriph Drivers:USART 3.5.0
